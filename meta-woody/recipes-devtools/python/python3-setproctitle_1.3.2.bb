SUMMARY = "The setproctitle module allows a process to change its title"
HOMEPAGE = "https://github.com/dvarrazzo/py-setproctitle"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://COPYRIGHT;md5=86d2d41b5f4f023f43466f8cb7adebaa"

SRC_URI[sha256sum] = "b9fb97907c830d260fa0658ed58afd48a86b2b88aac521135c352ff7fd3477fd"

inherit setuptools3 pypi

