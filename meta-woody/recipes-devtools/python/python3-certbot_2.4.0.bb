SUMMARY = "Certbot is a fully-featured, extensible client for the Let’s Encrypt CA"
HOMEPAGE = "https://github.com/certbot/certbot"
LICENSE = "Apache"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=16542115f15152bdc6d80c5b5d208e70"

SRC_URI[sha256sum] = "06bfde9e177a185fa7a7c0a8e533dfb03c6648ef90a205d3a8345e1966d5eb04"

inherit setuptools3 pypi
