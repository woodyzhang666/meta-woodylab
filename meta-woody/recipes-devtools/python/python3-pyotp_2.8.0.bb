SUMMARY = "a Python library for generating and verifying oneime passwords."
HOMEPAGE = "https://github.com/pyauth/pyotp"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f4889ab24aecac0a410d83c0323f9daf"

SRC_URI[sha256sum] = "c2f5e17d9da92d8ec1f7de6331ab08116b9115adbabcba6e208d46fc49a98c5a"

PYPI_SRC_URI = "https://files.pythonhosted.org/packages/7e/f9/4c2ec78572a2d25f669220b8b9700c1133905ff6af9bf93c010778e82c65/pyotp-2.8.0.tar.gz"

inherit setuptools3 pypi

